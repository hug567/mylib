## cmake/tests/test_import_config/defconfig
```kconfig
CONFIG_NUMBER_01=123
# CONFIG_BOOL_FALSE is not set
CONFIG_BOOL_TRUE=y
CONFIG_VAR_MODULE=m
CONFIG_STRING_01="string"
```
