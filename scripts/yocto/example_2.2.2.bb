# recipe样例
# yocto/poky版本：2.2.2
# 2024-03-09

# 必须要有的变量设置
SUMMARY = "example"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"
